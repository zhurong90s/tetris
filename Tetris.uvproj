# Keil uVision project Tetris.uvproj, settings and files
target Tetris (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TFT_LCD +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\STM32Lib\inc;.\app\app_h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/: main.c stm32f10x_it.c app_usart1.c app_tft.c app_tetris.c
  group CMSIS
    ./CMSIS/CM3/: core_cm3.c system_stm32f10x.c
    ./CMSIS/CM3/startup/: startup_stm32f10x_hd.s
  group STM32lLib
    ./STM32Lib/src/: stm32f10x_exti.c stm32f10x_fsmc.c misc.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c
